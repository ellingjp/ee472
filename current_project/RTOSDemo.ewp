# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: pa082, pe513, pe167, pe550, pe144, pe191, pe177, pa039, pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\FreeRTOS\source\include; C:\StellarisWare\; C:\StellarisWare\inc; C:\StellarisWare\utils; C:\StellarisWare\driverlib; C:\StellarisWare\boards\ek-lm3s8962\drivers; C:\StellarisWare\boards\ek-lm3s8962\; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.4\arm\examples\TexasInstruments\Stellaris\third_party\lwip-1.3.2\src\include\lwip; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.4\arm\examples\TexasInstruments\Stellaris\third_party\lwip-1.3.2\src\include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.4\arm\examples\TexasInstruments\Stellaris\third_party\lwip-1.3.2\ports\stellaris\include\; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.4\arm\examples\TexasInstruments\Stellaris\third_party\lwip-1.3.2\src\include\ipv4; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.4\arm\examples\TexasInstruments\Stellaris\third_party\lwip-1.3.2\apps\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application files
    ../lab5/code/: CircularBuffer.c CircularBuffer.h compute.c compute.h display.c display.h ekgCapture.c ekgCapture.h ekgProcess.c ekgProcess.h globals.c globals.h keyPad.c keyPad.h lwipopts.h main.c measure.c measure.h optfft.c optfft.h schedule.c schedule.h serial.c serial.h startup.c startup.h status.c status.h tables.c tcb.h timebase.c timebase.h warning.c warning.h
  group Library files
    ../../../../StellarisWare/driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ../../../../StellarisWare/boards/ek-lm3s8962/drivers/: rit128x96x4.c
    ../../../../StellarisWare/utils/: ustdlib.c
  group Scheduler files
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ../lab5/code/: startup_ewarm.c
