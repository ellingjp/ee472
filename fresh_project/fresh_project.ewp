# IAR project fresh_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCIncludePath2: required_files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fresh_project.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../lab3/code/: CircularBuffer.c CircularBuffer.h compute.c compute.h display.c display.h globals.c globals.h keyPad.c keyPad.h main.c measure.c measure.h rit128x96x4.c schedule.c schedule.h serial.c serial.h startup.c startup.h startup_ewarm.c status.c status.h task.h timebase.h timings.txt ustdlib.c warning.c warning.h
    required_files/driverlib/: driverlib-cm3.a
